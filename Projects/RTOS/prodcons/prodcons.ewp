# IAR project prodcons.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: F:\00_Embedded_Systems\ES_UTFPR\CMSIS-5.6.0; F:\00_Embedded_Systems\ES_UTFPR\CMSIS-5.6.0\CMSIS\Core\Include; F:\00_Embedded_Systems\ES_UTFPR\CMSIS-5.6.0\CMSIS\RTOS2\Include; F:\00_Embedded_Systems\ES_UTFPR\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include; F:\00_Embedded_Systems\ES_UTFPR\Projects\drivers; F:\00_Embedded_Systems\ES_UTFPR\Projects\Aula1\driverlib\ewarm\Exe; F:\00_Embedded_Systems\ES_UTFPR\TivaWare_C_Series-2.1.4.178
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: prodcons.bin
  ILINK.IlinkOutputFile: prodcons.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../drivers/: driverbuttons.c
    ../drivers/: driverleds.c
    ../../Aula1/driverlib/ewarm/Exe/: driverlib.a
    src/: prodcons.c RTX_Config.c rtx_lib.c startup_TM4C1294.s system_TM4C1294_TW.c
    ../../../CMSIS-5.6.0/CMSIS/RTOS2/RTX/Library/IAR/: RTX_CM4F.a
